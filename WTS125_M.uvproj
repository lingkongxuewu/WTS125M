# Keil uVision project WTS125_M.uvproj, settings and files
target 目标 1 (MCS-51)
  device: C8051F502 Silicon Labs
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM(0-0xFFF) CLOCK(24000000)
  output: WTS125_M +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: STARTUP.A51
    ./scr/: AdcDrv.c AngApp.c Calibration.c CalMcuT.c CmdSub.c Comm.c compass.c Delay.c Filter.c Flash.c Init.c Key.c Main.c ModBusCrc.c ModBusRtu.c Send.c Sensor.c Sub.c Timer.c
